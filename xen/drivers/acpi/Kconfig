## xen/drivers/acpi/Kconfig
```kconfig
config ACPI
	bool

config ACPI_LEGACY_TABLES_LOOKUP
	bool

config ACPI_NUMA
	def_bool y
	depends on ACPI && NUMA
```
